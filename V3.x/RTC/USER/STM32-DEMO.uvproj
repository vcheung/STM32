# Keil uVision project STM32-DEMO.uvproj, settings and files
target STM32-DEMO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\CMSIS;..\FWlib\inc;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c rtc.c usart1.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
